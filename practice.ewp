# IAR project practice.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: HSE_VALUE=8000000; STM32F40XX; STM32F4XX; USE_STDPERIPH_DRIVER; USE_STM32F4_DISCOVERY; ARM_MATH_CM4
  ICCARM.CCIncludePath2: User; Libraries\Device\STM32F4xx\Include; Libraries\STM32F4xx_StdPeriph_Driver\Include; Utilities\STM32F4-Discovery; Libraries\CMSIS\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: practice.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkAdditionalLibs: Utilities\STM32F4-Discovery\libPDMFilter_IAR.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Libraries/Device/STM32F4xx/Include
    Libraries/Device/STM32F4xx/Include/: stm32f4xx.h system_stm32f4xx.h
  group Libraries/STM32F4xx_StdPeriph_Driver/Include
    Libraries/STM32F4xx_StdPeriph_Driver/Include/: misc.h stm32f4xx_adc.h stm32f4xx_can.h stm32f4xx_crc.h stm32f4xx_cryp.h stm32f4xx_dac.h stm32f4xx_dbgmcu.h stm32f4xx_dcmi.h stm32f4xx_dma.h stm32f4xx_exti.h stm32f4xx_flash.h stm32f4xx_fsmc.h stm32f4xx_gpio.h stm32f4xx_hash.h stm32f4xx_i2c.h stm32f4xx_iwdg.h stm32f4xx_pwr.h stm32f4xx_rcc.h stm32f4xx_rng.h stm32f4xx_rtc.h stm32f4xx_sdio.h stm32f4xx_spi.h stm32f4xx_syscfg.h stm32f4xx_tim.h stm32f4xx_usart.h stm32f4xx_wwdg.h
  group Libraries/STM32F4xx_StdPeriph_Driver/Source
    Libraries/STM32F4xx_StdPeriph_Driver/Source/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group User
    User/: main.c microphone_driver.c microphone_driver.h pwm_led.c pwm_led.h startup_stm32f4xx.s stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h system_stm32f4xx.c
  group Utilities/STM32F4-Discovery
    Utilities/STM32F4-Discovery/: pdm_filter.h stm32f4_discovery.c stm32f4_discovery.h stm32f4_discovery_audio_codec.c stm32f4_discovery_audio_codec.h stm32f4_discovery_lis302dl.c stm32f4_discovery_lis302dl.h
